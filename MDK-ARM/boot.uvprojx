# Keil uVision project boot.uvprojx, settings and files
target boot (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0") TZ
  output: XXBOOT +hex
  AfterMake: fromelf --bincombined -o ./build/XXBOOT.bin ./build/XXBOOT.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=5 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32F030x8,USE_HAL_DRIVER
  c include: ../Core/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;../common;../common/clib/inc;../Application
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x200000c8 size 0x1f38
  group Application/MDK-ARM
    ./: startup_stm32f030x8.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_gpio.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_ll_usart.c stm32f0xx_ll_rcc.c stm32f0xx_ll_dma.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_exti.c stm32f0xx_ll_utils.c stm32f0xx_ll_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f0xx.c
  group clib
    ../common/clib/src/: cl_event_system.c cl_fsm.c cl_list.c cl_pool.c cl_queue.c cl_serialize.c
  group app
    ../common/: systime.c
    ../Application/: helper.c crc.c dfu.c sog_ymodem.c ymodem_helper.c ymodem_pack_parse.c led.c
software components: CMSIS:CORE 5.6.0
